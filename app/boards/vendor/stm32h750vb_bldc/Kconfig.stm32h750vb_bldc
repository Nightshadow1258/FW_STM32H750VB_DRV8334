## app/boards/vendor/stm32h750vb_bldc/board.yml
```yaml
board:
  name: stm32h750vb_bldc
  full_name: STM32H750VB BLDC
  vendor: vcc-gnd
  socs:
    - name: stm32h750xx
```
